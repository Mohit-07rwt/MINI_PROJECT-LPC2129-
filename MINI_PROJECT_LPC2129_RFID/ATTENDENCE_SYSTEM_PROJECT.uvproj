# Keil uVision project ATTENDENCE_SYSTEM_PROJECT.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: ATTENDENCE_SYSTEM_PROJECT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s RFID_project.c header.h
    ../vector/ARM/Interrupt/: header3.h
    ../CLASS_PGMS/: delay.c
    ../PRACTICE/LCD/4bit_lcd/: lcd_4bit_driver.c
    ../PRACTICE/UART0/: uart0_driver.c
